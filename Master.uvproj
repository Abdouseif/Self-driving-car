# Keil uVision project Master.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Master
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: Main.c startup.s
  group Library
    ./Library Support/: MotorDriver.c MotorDriver.h PORTS_INIT.c PORTS_INIT.h pwmPF.c pwmPF.h SensorInterface.c SensorInterface.h tm4c123gh6pm.h linesensors.c CompassInterface.c CompassInterface.h linesensors.h
